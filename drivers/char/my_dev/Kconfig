## drivers/char/my_dev/Kconfig
```kconfig
menu "my custom modules"
    config CUSTOM_HELLOWORLD
    tristate "hello world module support"
    default m
endmenu
```
